# Repository CoastRunnerCNC/coastrunner_cr1_pcbs

## KiCad design cr1_led_board/PCB/LEDIO.kicad_pcb

Board: 2 copper layers, 272.5 x 12.0 mm, 15 parts (1 on the bottom side), 10 nets.

Parts:
D1: LTST-S270KGKT; D_0603_1608Metric
D2, D3, D4, D5, D6, D7: TSAL4400; D_1206_3216Metric
FID1, FID2, FID3: Fiducial; Fiducial_0.5mm_Mask1mm
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: PJ-076B; CUI_PJ-076
J2: Conn_01x05; PinHeader_1x05_P2.54mm_Horizontal

Connections:
/5V_I_LIM: D1.2, J2.2
/24V_I_LIM: D2.2, J2.3
/LED_03V: D6.1, D7.2
/LED_06V: D5.1, D6.2
/LED_09V: D4.1, D5.2
/LED_12V: D3.1, D4.2
/LED_15V: D2.1, D3.2
/PROBE: D1.1, J1.1, J1.3, J2.1
/SPINDLE: J1.2, J2.5
GND: D7.1, J1.4, J1.5, J1.6, J2.4

## KiCad design cr1_uno_shield/PCB (KiCAD)/GrBLDC.kicad_pcb

File cr1_uno_shield/README.md:

# Coast Runner Uno Shield
Uno Shield for CR-1: closed loop spindle VFD + 4 stepper drivers
Main Controller PCB for CR-1.  Hardware version 3B

This is the first PCB shipped in CR-1.

PCB designed in KiCAD.

Board: 6 copper layers, 103.1 x 59.6 mm, 215 parts (8 on the bottom side), 145 nets.

Parts:
C1, C2, C3, C4, C5, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C37, C38, C40, C41, C42, C43, C58, C67, C72, C73, C74, C77, C80, C82, C87, C88: 220n; C_0603
C6, C7, C8, C9, C10, C11, C12, C13, C84, C85, C86: 680p; C_0603
C36, C39: 12p; C_0603
C44, C49, C52, C53, C54, C55, C56, C59, C60, C61, C62, C64, C65, C66, C89: 10u; C_1206
C45, C46, C47, C48, C50, C79: 33n; C_0603
C51, C57, C63: 330u; c_elec_10x10.5
C68, C69, C70, C71: 100u; c_elec_493-3953-2-ND_6.3x7.7
D1: LM4040; SOT-23
D2, D3: 6V Zener; D_SOD-123
D4: D_Zener; D_SMB
FID1, FID2, FID3: Fiducial; Fiducial_1.5mm_Mask3mm
H1, H2, H3, H4: MountingHole; MountingHole_2mm
HS1, HS2: Heat_Sink; HeatSink
IC1: ATMEGA16M1-A; TQFP-32_7x7mm_Pitch0.8mm
ILTC1: 0; ILTC
J1: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J2: 4910SCK; TestPoint_Pad_D1.0mm
J3: 4910SDI; TestPoint_Pad_D1.0mm
J4: 4910SDO; TestPoint_Pad_D1.0mm
J5: 4910STR; TestPoint_Pad_1.0x1.0mm
J6: Conn_02x02_Top_Bottom; PinHeader_2x02_P2.54mm_Vertical
P1: CONN_6; PinHeader_1x06_P2.54mm_Vertical
P2, P9, P10: CONN_8; PinHeader_1x08_P2.54mm_Vertical
P3, P6, P7: CONN_01X04; Pin_A98335-ND_1x04
P4: CONN_01X03; PinHeader_1x03_P2.54mm_Vertical
P5: CONN_01X05; PinHeader_1x05_P2.54mm_Vertical
P8: CONN_9; PinHeader_1x09_P2.54mm_Vertical
P11: CONN_2; PinHeader_1x02_P2.54mm_Vertical
P12: CONN_01X03; 277-1722-ND
P14: CONN_01X03; Pin_Header_277-1578-ND_3x01
P15: CONN_01X03; Socket_Strip_Straight_1x03
Q1, Q2, Q3, Q4, Q5, Q6: IRF5406
R1, R2, R20, R29, R33, R34, R53, R61, R76, R77, R78, R79, R80, R81: 1.47k; R_0603
R3, R4, R5, R6, R7, R8, R9, R10, R21, R22: 56k; R_0603
R11, R12, R13, R14, R15, R16, R17, R18: 0.09; R_1206
R19, R25, R26, R27, R30, R31, R32: 1k; R_0603
R23, R39, R41, R42, R44, R46, R47, R48, R52, R64, R68, R70, R72: 47; R_0603
R24, R28, R35, R36, R37, R66: DNP; R_0603
R38, R57, R58: .005; R_1206
R40, R43, R45, R49, R50, R51: 470k; R_0603
R54, R55, R56, R59, R60, R63, R83: 1k; R_0603_1608Metric
R62, R65: DNP; R_0603_1608Metric
R67, R69, R71, R73, R74, R75: 24.3k; R_0603
R82, R84: 1.47k; R_0603_1608Metric
U1, U2, U3, U4: DRV8818
U5: A4910; A4910-LQFP_48
Y1: 16M; Crystal_SMD_2016-4pin_2.0x1.6mm

Connections:
+24V: C18.2, C20.2, C22.2, C24.2, C26.1, C27.1, C28.1, C29.1, C37.1, C38.1, C40.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C88.1, C89.1, D4.1, ILTC1.2, P11.1, P14.1, Q1.D, Q3.D, Q5.D, R55.2, R59.2, R60.2, U1.15, U1.28, U2.15, U2.28, U3.15, U3.28, U4.15, U4.28, U5.7
/2V5REF: D1.1, R19.1, R56.2
/5V_LED: P5.2, R54.2
/24V_LED: P5.3, R55.1, R59.1, R60.1
/A0_STEP_X1_EN: IC1.31, P1.1, U1.27
/A1_Stepper_PMode: P1.2, R83.1
/A2_LIMIT_X1: IC1.2, P1.3, R82.1
/A3_64M1MISO: IC1.1, P1.4, R84.1
/A4_SPINDLE_OVERLOAD: IC1.7, IC1.12, P1.5
/A5_PROBE: C48.2, P1.6, R42.1
/A4910Fault: IC1.25, U5.17
/AHI: IC1.29, U5.18
/ALO: IC1.28, U5.19
/AVCC: C41.1, IC1.19, R23.2
/BHI: IC1.30, U5.20
/BLAC_XTAL1: C36.2, IC1.10, Y1.1
/BLAC_XTAL2: C39.1, IC1.11, Y1.3
/BLAC_aRef: C79.2, IC1.21
/BLDC_En: IC1.24, U5.12
/BLO: IC1.27, U5.21
/CA: C45.1, U5.2
/CB: C47.1, U5.45
/CC: C46.1, U5.40
/CHI: IC1.8, U5.22
/CLO: IC1.9, U5.23
/CP1: C73.2, C74.2, U5.5
/CP2: C73.1, C74.1, U5.4
/CSAM: C84.2, R73.1, R77.2, U5.34
/CSAP: C84.1, R67.1, R76.2, U5.33
/CSBM: C85.2, R74.1, R79.2, U5.31
/CSBP: C85.1, R69.1, R78.2, U5.30
/CSCM: C86.2, R75.1, R81.2, U5.28
/CSCP: C86.1, R71.1, R80.2, U5.27
/CUR_A: IC1.15, IC1.26, R73.2, U5.35
/CUR_B: IC1.18, IC1.22, R74.2, U5.32
/CUR_C: IC1.13, IC1.17, R75.2, U5.29
/D2_STEP_X: P10.6, U1.19, U2.19
/D3_STEP_Y: P10.5, U3.19
/D4_STEP_Z: P10.4, U4.19
/D5_DIR_X: P10.3, U1.3, U2.3
/D6_DIR_Y: P10.2, U3.3
/D7_DIR_Z: P10.1, U4.3
/D8_STEP_EN_n: P9.8, U1.26, U2.26, U3.26, U4.26
/D9_LIMIT_X2: C30.1, P9.7, R25.2
/D10_LIMIT_Y: C31.1, P9.6, R26.2
/D11_SPIN_PWM: P9.5, R21.2
/D12_LIMIT_Z: C32.1, P9.4, R27.2
/D13_SPIN_DIR: IC1.23, P9.3
/DECAY: C1.1, R1.2, R2.1, U1.5, U2.5, U3.5, U4.5
/ESTOP_Filtered: C77.1, D2.1, R64.2, U1.17, U2.17, U3.17, U4.17, U5.11
/ESTOP_n: P15.2, R61.2, R64.1
/GHA: R39.1, U5.48
/GHAZ: Q1.G, R39.2, R40.2
/GHB: R44.1, U5.43
/GHBZ: Q3.G, R44.2, R45.2
/GHC: R48.1, U5.38
/GHCZ: Q5.G, R48.2, R49.2
/GLA: R41.1, U5.47
/GLAZ: Q2.G, R41.2, R43.1
/GLB: R46.1, U5.42
/GLBZ: Q4.G, R46.2, R50.1
/GLC: R47.1, U5.37
/GLCZ: Q6.G, R47.2, R51.1
/HALL_A: IC1.6, IC1.32, J1.6, R29.2
/HALL_B: IC1.3, J1.4, R33.2
/HALL_C: J1.2, R34.2, R84.2
/ISET_A: R24.1, R67.2, R68.2
/ISET_B: R28.1, R69.2, R70.2
/ISET_C: R66.1, R71.2, R72.2
/LSSA: C54.2, C66.2, Q2.S, R38.2, R43.2, R76.1, U5.46
/LSSB: C53.2, C65.2, Q4.S, R50.2, R57.2, R78.1, U5.41
/LSSC: C59.2, C60.2, Q6.S, R51.2, R58.2, R80.1, U5.36
/PHASE_A: C45.2, P12.1, Q1.S, Q2.D, R40.1, U5.1
/PHASE_B: C47.2, P12.2, Q3.S, Q4.D, R45.1, U5.44
/PHASE_C: C46.2, P12.3, Q5.S, Q6.D, R49.1, U5.39
/PI_PRB: C50.2, R42.2, R52.1
/PI_X2LIM: C33.1, R25.1, R30.2
/PI_YLIM: C34.1, R26.1, R31.2
/PI_ZLIM: C35.1, R27.1, R32.2
/PROBE_NOISY: P5.1, R52.2, R53.2
/RESET_328p: D2.2, P2.3
/SPIN_PWM_to_Analog: C87.2, IC1.16, R21.1, R22.1
/Spindle_Wiper: J1.3, P5.5, R62.2
/VBRG: ILTC1.1, U5.8
/VREF_DIV: R20.1, R63.2
/VREF_Steppers: C72.1, R19.2, R63.1, R83.2, U1.8, U2.8, U3.8, U4.8
/VREG: C43.1, C44.1, U5.3
/X1LIM: P4.2, R65.1, R82.2
/X1_A1: P6.1, U1.4
/X1_A2: P6.2, U1.25
/X1_B1: P6.3, U1.11
/X1_B2: P6.4, U1.18
/X1_CP1: C19.1, U1.23
/X1_CP2: C19.2, U1.24
/X1_ISENA: R15.1, U1.1
/X1_ISENB: R11.1, U1.14
/X1_RCA: C6.1, R3.1, U1.6
/X1_RCB: C10.1, R7.1, U1.9
/X1_VCP: C18.1, U1.22
/X1_VGD: C14.1, U1.20
/X2LIM: P8.8, R30.1, R35.1
/X2_A1: P7.1, U2.4
/X2_A2: P7.2, U2.25
/X2_B1: P7.3, U2.11
/X2_B2: P7.4, U2.18
/X2_CP1: C21.1, U2.23
/X2_CP2: C21.2, U2.24
/X2_ISENA: R16.1, U2.1
/X2_ISENB: R12.1, U2.14
/X2_RCA: C7.1, R4.1, U2.6
/X2_RCB: C11.1, R8.1, U2.9
/X2_VCP: C20.1, U2.22
/X2_VGD: C15.1, U2.20
/YLIM: P8.5, R31.1, R36.1
/Y_A1: P3.1, U3.4
/Y_A2: P3.2, U3.25
/Y_B1: P3.3, U3.11
/Y_B2: P3.4, U3.18
/Y_CP1: C23.1, U3.23
/Y_CP2: C23.2, U3.24
/Y_ISENA: R17.1, U3.1
/Y_ISENB: R13.1, U3.14
/Y_RCA: C8.1, R5.1, U3.6
/Y_RCB: C12.1, R9.1, U3.9
/Y_VCP: C22.1, U3.22
/Y_VGD: C16.1, U3.20
/ZLIM: P8.2, R32.1, R37.1
/Z_A1: J6.1, U4.4
/Z_A2: J6.2, U4.25
/Z_B1: J6.3, U4.11
/Z_B2: J6.4, U4.18
/Z_CP1: C25.1, U4.23
/Z_CP2: C25.2, U4.24
/Z_ISENA: R18.1, U4.1
/Z_ISENB: R14.1, U4.14
/Z_RCA: C9.1, R6.1, U4.6
/Z_RCB: C13.1, R10.1, U4.9
/Z_VCP: C24.1, U4.22
/Z_VGD: C17.1, U4.20
/a4910_SCK: J2.1, U5.14
/a4910_SDI: J3.1, U5.15
/a4910_SDO: J4.1, U5.16
/a4910_STRn: J5.1, U5.13
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.1, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C48.1, C49.2, C50.1, C51.2, C52.2, C55.2, C56.2, C57.2, C58.2, C61.2, C62.2, C63.2, C64.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C77.2, C79.1, C80.2, C82.2, C87.1, C88.2, C89.2, D1.2, D3.2, D4.2, HS1.1, HS1.2, HS2.1, HS2.2, IC1.5, IC1.20, J1.1, P2.6, P2.7, P4.3, P5.4, P8.3, P8.6, P8.9, P9.2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
VCC: C2.1, C3.1, C4.1, C5.1, C42.1, C49.1, C58.1, C80.1, C82.1, D3.1, IC1.4, J1.5, P2.5, P4.1, P8.1, P8.4, P8.7, P15.1, R1.1, R23.1, R24.2, R28.2, R29.1, R33.1, R34.1, R35.2, R36.2, R37.2, R53.1, R54.1, R56.1, R65.2, R66.2, U1.10, U1.12, U1.13, U2.10, U2.12, U2.13, U2.27, U3.10, U3.12, U3.13, U3.27, U4.10, U4.12, U4.13, U4.27, U5.10

File Coast Runner_BOMs.csv:

Component Count:,215,,,,,
Reference Designator,Quantity,Value,Footprint,Description,Manufacturer,MFPN
"C1, C2, C3, C4, C5, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C37, C38, C40, C41, C42, C43, C58, C67, C72, C73, C74, C77, C80, C82, C87, C88",43,220n,SMD:C_0603,"Capacitor, 0.220uF,x7r,50v,+/-10%, 0603",Samsung,CL10B224KB8VPNC
"C6, C7, C8, C9, C10, C11, C12, C13, C84, C85, C86",11,680p,SMD:C_0603,"Capacitor,680pF,50V,cog,0603,5%",Samsung,CL10C681JB8NNNC
"C36, C39",2,12p,SMD:C_0603,"Capacitor,12pF,cog,50v,0603,5%",Samsung,CL10C120JB8NNNC
"C44, C49, C52, C53, C54, C55, C56, C59, C60, C61, C62, C64, C65, C66, C89",15,10u,SMD:C_1206,"Capacitor,10uF,x7r,50v,1206,10%",Samsung,CL31B106KBHNNNE
"C45, C46, C47, C48, C50, C79",6,33n,SMD:C_0603,"Capacitor,0.033uf,x7r,50v,10%,0603",Samsung,CL10B333KB8WPNC
"C51, C57, C63",3,330u,SMD:c_elec_10x10.5,"Capacitor,Electrolytic,330µF,20%,35V,10x10.5",Nichicon,UCL1V331MNL1GS
"C68, C69, C70, C71",4,100u,SMD:c_elec_6.3x7.7,"Capacitor,Electrolytic,100µF,20%,35V,6.3x7.7",Nichicon,UCL1V101MCL6GS
D1,1,LM4040,SOT-23-3,IC VREF SHUNT 1% SOT23-3,Microchip Tech,LM4040DYM3-2.5-TR
"D2, D3",2,6V Zener,SOD-123,DIODE ZENER 6V 500MW SOD123,Diodes Inc,MMSZ5233B-7-F
D4,1,D_Zener,SMD:D_SMB,DIODE ZENER 30V 1.5W DO214AA,Vishay,SMZJ3800B-E3/52
"HS1, HS2",2,Heat_Sink,,Heat Sink TO-252 (DPak) Aluminum 0.8W @ 30°C Top Mount,Aavid,573100D00000G
IC1,1,ATMEGA16M1-A,TQFP-32,"IC,MCU,8Bit,32KB,Flash,32TQFP",Microchip Tech,ATMEGA32M1-AUR
J1,1,Conn_02x03,,"Connector,Header,2.54mm,02x03,Vertical,15.0uin Gold,Contact Mating Length=8.13mm",Molex,10977066
J6,1,Conn_02x02,,"Connector,Header,2.54mm,02x02,Vertical",Sullins,PRPC002DFAN-RC
P1,1,CONN_6,,"Connector,Header,2.54mm,01x06,Vertical,15.0uin Gold,Contact Mating Length=6.10mm",Molex,22284063
"P2, P9, P10",3,CONN_8,,"Connector,Header,2.54mm,01x08,Vertical,15.0uin Gold,Contact Mating Length=6.10mm",Molex,22284083
"P3, P6, P7",3,CONN_01X04,,"Connector,Header,Male,Shrouded 1-wall,2.65mm,Vertical",Sullins,SWR25X-NRTC-S04-ST-BA
"P4, P15",2,CONN_01X03,,"Connector,Header,2.54mm,01x03,Vertical,15.0uin Gold,Contact Mating Length=8.13mm",Molex,22284034
P5,1,CONN_01X05,,"Connector,Header,2.54mm,01x05,Vertical,15.0uin Gold,Contact Mating Length=8.13mm",Molex,22285054
P8,1,CONN_9,,"Connector,Header,2.54mm,01x09,Vertical,15.0uin Gold,Contact Mating Length=8.13mm",Molex,22284094
P11,1,CONN_01X02,,"Connector,header,2.54mm,vertical,1x2,15.0uin Gold,Contact Mating Length=8.13mm",Molex,22284024
P12,1,CONN_01X03,,"Connector,Terminal Block,Combicon,3.5mm,45°",Phoenix ,1988969
P14,1,CONN_01X03,,"Connector,Terminal Block,Combicon,5mm,0°",Phoenix ,1987737
"Q1, Q2, Q3, Q4, Q5, Q6",6,IRF5406,8-PQFN,"Mosfet,N-Channel,60V,8-PQFN",Infineon,IRFH5406TRPBF
"R1, R2, R20, R29, R33, R34, R53, R61, R76, R77, R78, R79, R80, R81, R82, R84",16,1.47k,Resistors_SMD:R_0603,"Resistor,1.47k,1%, 1/10W 0603",Yageo,RC0603FR-071K47L
"R3, R4, R5, R6, R7, R8, R9, R10, R21, R22",10,56k,Resistors_SMD:R_0603,"Resistor,56k,1%,100mw,0603,100ppm",Samsung,RC1608F563CS
"R11, R12, R13, R14, R15, R16, R17, R18",8,0.09,Resistors_SMD:R_1206,"Resistor,Current Sense,91mOhms,1%,0.5W,1206",TE Connectivity,RLP73N2BR091FTD
"R19, R25, R26, R27, R30, R31, R32, R54, R55, R56, R59, R60, R63, R83",14,1k,Resistors_SMD:R_0603,"Resistor,1K OHM 1% 1/10W 0603",Samsung,RC1608F102CS
"R23, R39, R41, R42, R44, R46, R47, R48, R52, R64, R68, R70, R72",13,47,Resistors_SMD:R_0603,"Resistor,47,1%, 1/10W 0603",Samsung,RC1608F470CS
"R24, R28, R35, R36, R37, R62, R65, R66",8,DNP,Resistors_SMD:R_0603,"Resistor, NOT POPULATED",,
"R38, R57, R58",3,0.005,Resistors_SMD:R_1206,"Resistor,Current Sense,5mOhms,1%,1W,1206",Ohmite,LVT12R0050FER
"R40, R43, R45, R49, R50, R51",6,470k,Resistors_SMD:R_0603,"Resistor,470k,1%, 1/10W 0603",Samsung,RC1608F474CS
"R67, R69, R71, R73, R74, R75",6,24.3k,Resistors_SMD:R_0603,"Resistor,24.3k,1%,1\10W, 0603",Yageo,RC0603FR-0724K3L
"U1, U2, U3, U4",4,DRV8818,28-HTSSOP,"IC,Driver,Half Bridge,28-HTSSOP",Texas Instruments,DRV8818PWPR
U5,1,A4910,LQFP_48,"IC,Motor Driver,CMOS,Serial,48-LQFP-EP (7x7)",Allegro,A4910KJPTR-T
Y1,1,16MHz,SMD_2016-4pin_2.0x1.6mm,"Crystal,16.0000MHz,12pF,SMD",ECS Inc,ECS-160-12-37B-CTN-TR

## Commit log

2024-05-30 Adding Gerber files, BOM
2024-05-30 Adding LED stuff to BOM
